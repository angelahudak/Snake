# Keil uVision project Snake.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MKL46Z256xxx4 NXP
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IRAM(0x1FFFE000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Snake
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: Exercise11_C.h snake.c snake.s Custom_IO_Ex06.lib
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
